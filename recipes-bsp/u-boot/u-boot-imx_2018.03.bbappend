FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://mx6ull_lm16_igw.patch"
#SRC_URI += "file://mx6ull_lumi_mieu01_defconfig;subdir=git/configs"
